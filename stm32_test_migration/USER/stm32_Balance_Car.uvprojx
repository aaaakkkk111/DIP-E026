# Keil uVision project stm32_Balance_Car.uvprojx, settings and files
target stm32RCT6_Balance_Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_Balance_Car_L +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CMSIS;..\FWLib\inc;..\BSP;..\BSP\Delay;..\BSP\Enconder;..\BSP\IIC_Software;..\BSP\Motor;..\BSP\MPU6050;..\BSP\MPU6050\DMP;..\BSP\Usart1;..\BSP\INT_Sever;..\BSP\Battery;..\APP;..\APP\filter;..\APP\KF;..\APP\PID;..\BSP\OLED;..\BSP\Key;..\BSP\Beep;..\BSP\LED;..\BSP\Timer;..\BSP\Ultrasonic;..\BSP\IRtracking;..\BSP\ElE_Track;..\BSP\CCD;..\BSP\Bluetooth;..\BSP\Lidar;..\BSP\PS2;..\APP\OLED_Show;..\APP\mode;..\APP\K210;..\APP\Lidar;..\APP\TestAssist
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f10x_it.c AllHeader.h myenum.h
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group BSP
    ../BSP/: bsp.c
    ../BSP/Delay/: delay.c
    ../BSP/Enconder/: encoder.c
    ../BSP/IIC_Software/: IOI2C.c
    ../BSP/Motor/: motor.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/Usart1/: usart.c bsp_usart2.c
    ../BSP/INT_Sever/: intsever.c
    ../BSP/Battery/: bsp_battery.c
    ../BSP/OLED/: bsp_oled_i2c.c bsp_oled.c oled_fonts.c
    ../BSP/Beep/: bsp_beep.c
    ../BSP/LED/: bsp_LED.c
    ../BSP/Timer/: bsp_timer.c
    ../BSP/Key/: bsp_key.c
    ../BSP/Ultrasonic/: bsp_ultrasonic.c
    ../BSP/IRtracking/: bsp_irtracking.c
    ../BSP/ElE_Track/: bsp_ele_track.c
    ../BSP/CCD/: bsp_ccd.c
    ../BSP/Bluetooth/: bsp_bluetooth.c
    ../BSP/Lidar/: bsp_lidar.c
    ../BSP/PS2/: bsp_ps2.c
  group APP
    ../APP/: app_control.c app_motor.c app_tracking.c app_ccd_tracking.c app_ele_tracking.c
    ../APP/PID/: pid_control.c
    ../BSP/Bluetooth/: app_bluetooth.c
    ../BSP/PS2/: app_ps2.c
    ../APP/mode/: app_mode.c
    ../APP/OLED_Show/: oled_show.c
  group TEST Assist
    ../APP/TestAssist/: test_assist.c neural_actor.c
  group DMP
    ../BSP/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group algorithm_my
    ../APP/filter/: filter.c
    ../APP/KF/: KF.c
  group K210
    ../APP/K210/: app_k210.c app_k210_AI.c app_line.c app_follow.c
  group LiDar
    ../APP/Lidar/: app_lidar.c app_lidar_car.c
